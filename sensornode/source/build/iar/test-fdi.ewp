# IAR project test-fdi.ewp, settings and files
configuration debug (RX, debug)
  General.OGChipSelectMenu: R5F51118 R5F51118
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x80
  General.IStackSize: 0x400
  General.HeapSize: 0x1000
  ICCRX.CCDefines: ASSERT(x)=if(!(x)) BSP_SysBrk()
  ICCRX.CCIncludePath2: $MICRIUM_CFG_DIR$; $MICRIUM_BSP_ROOT$\include; ..\..\libemqtt; $MICRIUM_ROOT$\Software\uCOS-III\Ports\Renesas\RX\IAR; $MICRIUM_ROOT$\Software\uCOS-III\Source; $MICRIUM_ROOT$\Software\uCOS-III; $MICRIUM_ROOT$\Software\uC-CPU; $MICRIUM_ROOT$\Software\uC-CPU\RX\IAR; $MICRIUM_ROOT$\Software\uC-LIB; $MICRIUM_ROOT$\Software\uC-Common; $MICRIUM_ROOT$\Software\uC-Common\KAL; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\include\AR6002; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\stack_common; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\wmi; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\stack_custom; $MICRIUM_ROOT$\Software\uC-USB-Device\; $MICRIUM_ROOT$\Software\uC-USB-Device\Class\MSC\Storage\uC-FS\V4; $MICRIUM_ROOT$\Software\uC-FS; $MICRIUM_ROOT$\Software\uC-FS\FAT; $MICRIUM_ROOT$\Software\uC-FS\OS\uCOS-III; $MICRIUM_ROOT$\Software\uC-FS\Source; $MICRIUM_ROOT$\Software\uC-Clk\Source; $MICRIUM_ROOT$\Software\APP\SmartHomeGwy-Sim\Source; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic\Source; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic\TCPIP\Source
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  OBJCOPY.OOCOutputFile: test-fdi.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkr5f51118.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: debug\lib\libbsp.a; debug\lib\libemqtt.a; debug\lib\librtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (RX)
  as the first configuration, except:
  ILINK.IlinkAdditionalLibs: release\lib\libbsp.a; release\lib\libemqtt.a; release\lib\librtos.a
  group (top)
    ../../tests/fdi/: main.c
