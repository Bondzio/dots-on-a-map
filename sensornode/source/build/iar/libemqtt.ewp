# IAR project libemqtt.ewp, settings and files
configuration debug (RX, debug)
  General.OGChipSelectMenu: RX100 Generic RX100
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: $APP_ROOT$\libemqtt\include; $MICRIUM_CFG_DIR$; $MICRIUM_BSP_ROOT$\include; $MICRIUM_ROOT$\Software\uC-Common\KAL; $MICRIUM_ROOT$\Software\uC-LIB; $MICRIUM_ROOT$\Software\uC-TCPIP-Offload\Dev\WiFi\QCA400x; $MICRIUM_ROOT$\Software\uC-TCPIP-Offload\Dev\WiFi\QCA400x\atheros_wifi; $MICRIUM_ROOT$\Software\uC-TCPIP-Offload\Dev\WiFi\QCA400x\atheros_wifi\include; $MICRIUM_ROOT$\Software\uC-TCPIP-Offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-Offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\include; $MICRIUM_ROOT$\Software\uC-CPU; $MICRIUM_ROOT$\Software\uC-CPU\RX\IAR
  ICCRX.IccExtraOptions: --no_size_limit
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: libmqtt.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (RX, debug)
  as the first configuration, except:
  ICCRX.CCIncludePath2: $APP_ROOT$\libemqtt\include; $MICRIUM_CFG_DIR$; $MICRIUM_ROOT$\Software\uC-Common\KAL; $MICRIUM_ROOT$\Software\uC-LIB; $MICRIUM_ROOT$\Software\uC-TCPIP-Offload\Dev\WiFi\QCA400x; $MICRIUM_ROOT$\Software\uC-TCPIP-Offload\Dev\WiFi\QCA400x\atheros_wifi; $MICRIUM_ROOT$\Software\uC-TCPIP-Offload\Dev\WiFi\QCA400x\atheros_wifi\include; $MICRIUM_ROOT$\Software\uC-TCPIP-Offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-Offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\include; $MICRIUM_ROOT$\Software\uC-CPU; $MICRIUM_ROOT$\Software\uC-CPU\RX\IAR
configuration rx231-vibration-debug (RX, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: RX23x Generic RX23x
  group client
    ../../libemqtt/client/: net_if_qcom.c
  group include
    ../../libemqtt/include/: emqtt.h
  group source
    ../../libemqtt/src/: emqtt.c
