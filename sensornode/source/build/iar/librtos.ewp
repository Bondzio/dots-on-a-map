# IAR project librtos.ewp, settings and files
configuration debug (RX, debug)
  General.OGChipSelectMenu: RX100 Generic RX100
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: $MICRIUM_CFG_DIR$; $MICRIUM_BSP_ROOT$\include; $MICRIUM_ROOT$\Software\uCOS-III\Ports\Renesas\RX\IAR; $MICRIUM_ROOT$\Software\uCOS-III\Source; $MICRIUM_ROOT$\Software\uCOS-III; $MICRIUM_ROOT$\Software\uC-CPU; $MICRIUM_ROOT$\Software\uC-CPU\RX\IAR; $MICRIUM_ROOT$\Software\uC-LIB; $MICRIUM_ROOT$\Software\uC-Common; $MICRIUM_ROOT$\Software\uC-Common\KAL; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\include\AR6002; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\stack_common; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\wmi; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\stack_custom; $MICRIUM_ROOT$\Software\uC-USB-Device\; $MICRIUM_ROOT$\Software\uC-USB-Device\Class\MSC\Storage\uC-FS\V4; $MICRIUM_ROOT$\Software\uC-FS; $MICRIUM_ROOT$\Software\uC-FS\FAT; $MICRIUM_ROOT$\Software\uC-FS\OS\uCOS-III; $MICRIUM_ROOT$\Software\uC-FS\Source; $MICRIUM_ROOT$\Software\uC-Clk\Source; $MICRIUM_ROOT$\Software\APP\SmartHomeGwy-Sim\Source; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic\Source; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic\TCPIP\Source
  ICCRX.IccExtraOptions: --no_size_limit
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: librtos.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (RX)
  as the first configuration, except:
configuration rx231-vibration-debug (RX, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: RX23x Generic RX23x
  ICCRX.CCDefines: RX231
  group cfg
    ../../Micrium/cfg/: app_cfg.h app_usbd_cfg.h bsp_cfg.h clk_cfg.h cpu_cfg.h fs_app_cfg.h fs_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h probe_com_cfg.h qca_cfg.c qca_cfg.h usbd_cfg.h usbd_dev_cfg.c usbd_dev_cfg.h
  group uC-Clk/OS/uC/OS-III
    ../../Micrium/Software/uC-Clk/OS/uCOS-III/: clk_os.c
  group uC-Clk/Source
    ../../Micrium/Software/uC-Clk/Source/: clk.c clk.h
  group uC-Common
    ../../Micrium/Software/uC-Common/: common.h common_err.h
  group uC-Common/KAL
    ../../Micrium/Software/uC-Common/KAL/: kal.h
  group uC-Common/KAL/uCOS-III
    ../../Micrium/Software/uC-Common/KAL/uCOS-III/: kal.c
  group uC-CPU
    ../../Micrium/Software/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uC-CPU/RX/IAR
    ../../Micrium/Software/uC-CPU/RX/IAR/: cpu.h
  group uC-FS/Dev/DataFlash
    ../../Micrium/Software/uC-FS/Dev/DataFlash/: df_rx.c fs_dev_dataflash.c fs_dev_dataflash.h
  group uC-FS/Dev/RAMDisk
    ../../Micrium/Software/uC-FS/Dev/RAMDisk/: fs_dev_ramdisk.c fs_dev_ramdisk.h
  group uC-FS/FAT
    ../../Micrium/Software/uC-FS/FAT/: fs_fat.c fs_fat.h fs_fat_dir.c fs_fat_dir.h fs_fat_entry.c fs_fat_entry.h fs_fat_fat12.c fs_fat_fat12.h fs_fat_fat16.c fs_fat_fat16.h fs_fat_fat32.c fs_fat_fat32.h fs_fat_file.c fs_fat_file.h fs_fat_journal.c fs_fat_journal.h fs_fat_lfn.c fs_fat_lfn.h fs_fat_sfn.c fs_fat_sfn.h fs_fat_type.h
  group uC-FS/OS/uC/OS-III
    ../../Micrium/Software/uC-FS/OS/uCOS-III/: fs_os.c fs_os.h
  group uC-FS/Source
    ../../Micrium/Software/uC-FS/Source/: fs.c fs.h fs_api.c fs_api.h fs_buf.c fs_buf.h fs_cache.c fs_cache.h fs_cfg_fs.h fs_ctr.h fs_def.h fs_dev.c fs_dev.h fs_dir.c fs_dir.h fs_entry.c fs_entry.h fs_err.h fs_file.c fs_file.h fs_inc.h fs_partition.c fs_partition.h fs_sys.c fs_sys.h fs_type.h fs_unicode.c fs_unicode.h fs_util.c fs_util.h fs_vol.c fs_vol.h
  group uC-LIB
    ../../Micrium/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-Probe/Target/Source
    ../../Micrium/Software/uC-Probe/Target/Communication/Generic/Source/: probe_com.c probe_com.h
  group uC-Probe/Target/TCPIP
    ../../Micrium/Software/uC-Probe/Target/Communication/Generic/TCPIP/Source/: probe_tcpip.h
  group uC-Probe/Target/TCPIP/OS
    ../../Micrium/Software/uC-Probe/Target/Communication/Generic/TCPIP/OS/uCOS-III/: probe_tcpip_os.c
  group uC-Probe/Target/TCPIP/port
    ../../Micrium/Software/uC-Probe/Target/Communication/Generic/TCPIP/Source/port/qcom/: probe_tcpip.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/: qca.c qca.h qca_type.h
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/: atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h osal.h qcom_api.h qcom_legacy.h
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/api_interface
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/bmi
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/bmi/: bmi.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/driver
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/hcd
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/hcd/: spi_hcd.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/htc
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/htc/: htc.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/hw_interface
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/hw_interface/: hw_api.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/include
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h dset.h dset_api.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/reorder
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/reorder/: rcv_aggr.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/stack_common
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/stack_common/: api_stack_offload.c common_stack_offload.h
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/storerecall
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/storerecall/: dset.c dset_api.c storerecall.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/util
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/util/: util.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/common_src/wmi
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/common_src/wmi/: wmi.c wmi_host.h
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/custom_src/api_interface
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/custom_src/api_interface/: cust_api_wmi_rx.c qcom_api.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/custom_src/driver
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/custom_src/hw_interface
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/custom_src/hw_interface/: cust_spi_hcd.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/custom_src/include
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/custom_src/include/: a_config.h a_osapi.h a_types.h athendpack.h athstartpack.h cust_context.h cust_netbuf.h custom_api.h custom_spi_api.h custom_wlan_api.h wlan_config.h
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/custom_src/osal
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/custom_src/osal/: osal.c
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/custom_src/stack_offload
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c custom_stack_offload.h
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/include
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h targaddrs.h wlan_defs.h wmi.h
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/include/AR6002
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/include/AR6002/: AR6K_version.h
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/include/AR6002/hw2.0/hw
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/include/AR6002/hw2.0/hw/: apb_map.h gpio_reg.h mbox_host_reg.h mbox_reg.h rtc_reg.h si_reg.h uart_reg.h vmc_reg.h
  group uC-TCPIP-offload/Dev/WiFi/QCA400X/atheros_wifi/include/AR6002/hw4.0/hw
    ../../Micrium/Software/uC-TCPIP-Offload/Dev/WiFi/QCA400x/atheros_wifi/include/AR6002/hw4.0/hw/: rtc_reg.h rtc_wlan_reg.h
  group uC-USB-Device/Class/MSC
    ../../Micrium/Software/uC-USB-Device/Class/MSC/: usbd_msc.c usbd_msc.h usbd_msc_os.h usbd_scsi.c usbd_scsi.h
  group uC-USB-Device/Class/MSC/OS
    ../../Micrium/Software/uC-USB-Device/Class/MSC/OS/uCOS-III/: usbd_msc_os.c
  group uC-USB-Device/Class/MSC/Storage/uC-FSv4
    ../../Micrium/Software/uC-USB-Device/Class/MSC/Storage/uC-FS/V4/: usbd_storage.c usbd_storage.h
  group uC-USB-Device/Drivers/RX600
    ../../Micrium/Software/uC-USB-Device/Drivers/RX600/: usbd_drv_rx600.c usbd_drv_rx600.h
  group uC-USB-Device/OS/uCOS-III
    ../../Micrium/Software/uC-USB-Device/OS/uCOS-III/: usbd_os.c
  group uC-USB-Device/Source
    ../../Micrium/Software/uC-USB-Device/Source/: usbd_core.c usbd_core.h usbd_ep.c usbd_internal.h
  group uCOS-III/Ports/RX
    ../../Micrium/Software/uCOS-III/Ports/Renesas/RX/IAR/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOS-III/Source
    ../../Micrium/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
