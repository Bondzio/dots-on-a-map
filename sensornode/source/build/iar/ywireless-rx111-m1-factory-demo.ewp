# IAR project ywireless-rx111-m1-factory-demo.ewp, settings and files
configuration debug (RX, debug)
  General.OGChipSelectMenu: R5F51118 R5F51118
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x200
  General.IStackSize: 0x700
  General.HeapSize: 0x1000
  ICCRX.CCDefines: ASSERT(x)=do{if(!(x)) BSP_SysBrk();}while(0)
  ICCRX.CCIncludePath2: $MICRIUM_CFG_DIR$; $MICRIUM_BSP_ROOT$\include; $APP_ROOT$\libemqtt\include; $MICRIUM_ROOT$\Software\uCOS-III\Ports\Renesas\RX\IAR; $MICRIUM_ROOT$\Software\uCOS-III\Source; $MICRIUM_ROOT$\Software\uCOS-III; $MICRIUM_ROOT$\Software\uC-CPU; $MICRIUM_ROOT$\Software\uC-CPU\RX\IAR; $MICRIUM_ROOT$\Software\uC-LIB; $MICRIUM_ROOT$\Software\uC-Common; $MICRIUM_ROOT$\Software\uC-Common\KAL; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\include\AR6002; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\stack_common; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\wmi; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\stack_custom; $MICRIUM_ROOT$\Software\uC-USB-Device\; $MICRIUM_ROOT$\Software\uC-USB-Device\Class\MSC\Storage\uC-FS\V4; $MICRIUM_ROOT$\Software\uC-FS; $MICRIUM_ROOT$\Software\uC-FS\FAT; $MICRIUM_ROOT$\Software\uC-FS\OS\uCOS-III; $MICRIUM_ROOT$\Software\uC-FS\Source; $MICRIUM_ROOT$\Software\uC-Clk\Source; $MICRIUM_ROOT$\Software\APP\SmartHomeGwy-Sim\Source; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic\Source; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic\TCPIP\Source
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  OBJCOPY.OOCOutputFile: ywireless-rx111-m1-factory-demo.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: debug\lib\libbsp.a; debug\lib\libemqtt.a; debug\lib\librtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (RX)
  as the first configuration, except:
  General.StackSize: 0x80
  General.IStackSize: 0x400
  ICCRX.CCDefines: ASSERT(x)=if(!(x)) BSP_SysBrk()
  ICCRX.CCIncludePath2: $MICRIUM_CFG_DIR$; $MICRIUM_BSP_ROOT$\include; ..\..\libemqtt\include; $MICRIUM_ROOT$\Software\uCOS-III\Ports\Renesas\RX\IAR; $MICRIUM_ROOT$\Software\uCOS-III\Source; $MICRIUM_ROOT$\Software\uCOS-III; $MICRIUM_ROOT$\Software\uC-CPU; $MICRIUM_ROOT$\Software\uC-CPU\RX\IAR; $MICRIUM_ROOT$\Software\uC-LIB; $MICRIUM_ROOT$\Software\uC-Common; $MICRIUM_ROOT$\Software\uC-Common\KAL; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\include\AR6002; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\stack_common; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\wmi; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\stack_custom; $MICRIUM_ROOT$\Software\uC-USB-Device\; $MICRIUM_ROOT$\Software\uC-USB-Device\Class\MSC\Storage\uC-FS\V4; $MICRIUM_ROOT$\Software\uC-FS; $MICRIUM_ROOT$\Software\uC-FS\FAT; $MICRIUM_ROOT$\Software\uC-FS\OS\uCOS-III; $MICRIUM_ROOT$\Software\uC-FS\Source; $MICRIUM_ROOT$\Software\uC-Clk\Source; $MICRIUM_ROOT$\Software\APP\SmartHomeGwy-Sim\Source; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic\Source; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic\TCPIP\Source
  ILINK.IlinkIcfFile: lnkr5f51118.icf
  ILINK.IlinkAdditionalLibs: release\lib\libbsp.a; release\lib\libemqtt.a; release\lib\librtos.a
configuration rx231-vibration-debug (RX, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: R5F52318 R5F52318
  ICCRX.CCDefines: ASSERT(x)=do{if(!(x)) BSP_SysBrk();}while(0); RX231
  OBJCOPY.OOCOutputFile: ywireless-rx231-m1-vibration-detection.hex
  ILINK.IlinkOutputFile: ywireless-rx231-m1-vibration-detection.out
  ILINK.IlinkAdditionalLibs: rx231-vibration-debug\Exe\libbsp.a; rx231-vibration-debug\Exe\librtos.a
  group (top)
    ../../: app.c app_isl29033.c app_isl29033.h app_lora_node.c app_lora_node.h app_m1.c app_m1.h app_util.c app_util.h app_wifi.c app_wifi.h app_wifi_util.c app_wifi_util.h cli.c cli.h nmea.c nmea.h sx1276.c sx1276.h
