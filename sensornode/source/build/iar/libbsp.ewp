# IAR project libbsp.ewp, settings and files
configuration debug (RX, debug)
  General.OGChipSelectMenu: RX100 Generic RX100
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: ASSERT(x)=do{if(!(x)) BSP_SysBrk();}while(0); ENABLE_PROBE_COM
  ICCRX.CCDiagSuppress: Pe1818
  ICCRX.CCIncludePath2: $MICRIUM_BSP_ROOT$\include; $MICRIUM_CFG_DIR$; $MICRIUM_ROOT$\Software\uC-CLK\Source; $MICRIUM_ROOT$\Software\uC-CPU; $MICRIUM_ROOT$\Software\uC-CPU\RX\IAR; $MICRIUM_ROOT$\Software\uC-LIB; $MICRIUM_ROOT$\Software\uC-Common; $MICRIUM_ROOT$\Software\uC-Common\KAL; $MICRIUM_ROOT$\Software\uCOS-III\Source; $MICRIUM_ROOT$\Software\uCOS-III\Ports\Renesas\RX\IAR; $MICRIUM_ROOT$\Software\uC-FS; $MICRIUM_ROOT$\Software\uC-FS\Source; $MICRIUM_ROOT$\Software\uC-FS\FAT; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\include\AR6002; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\stack_common; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\common_src\wmi; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\include; $MICRIUM_ROOT$\Software\uC-TCPIP-offload\Dev\WiFi\QCA400x\atheros_wifi\custom_src\stack_custom; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic; $MICRIUM_ROOT$\Software\uC-Probe\Target\Communication\Generic\Source; $MICRIUM_ROOT$\Software\uC-USB-Device
  ICCRX.IccExtraOptions: --no_size_limit
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: libbsp.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: ASSERT(x)=if(!(x)) BSP_SysBrk()
configuration rx231-vibration-debug (RX, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: RX23x Generic RX23x
  ICCRX.CCDefines: ASSERT(x)=do{if(!(x)) BSP_SysBrk();}while(0); ENABLE_PROBE_COM; RX231
  group (top)
    ../../Micrium/bsp/renesas/ywireless-rx111/source/: sci9_i2c_bsp.c
  group include
    ../../Micrium/bsp/renesas/ywireless-rx111/include/: bsp.h bsp_int.h bsp_led.h bsp_spi.h bsp_switch.h bsp_sys.h iodefine.h iodefine.rx111.h iodefine.rx231.h m1_bsp.h qca_bsp.h riic_i2c_bsp.h usbd_bsp.h
  group source
    ../../Micrium/bsp/renesas/ywireless-rx111/source/: bsp.c bsp_int.c bsp_int_vect_tbl.c bsp_led.c bsp_spi.c bsp_switch.c bsp_sys.c cpu_bsp.c m1_bsp.c os_bsp.c qca_bsp.c riic_i2c_bsp.c sci0_uart_bsp.c sci1_i2c_bsp.c sci1_spi_bsp.c sci1_uart_bsp.c sci6_i2c_bsp.c usbd_bsp.c
  group source/startup
    ../../Micrium/bsp/renesas/ywireless-rx111/source/startup/: sys_init.c
  group source/startup/iar
    ../../Micrium/bsp/renesas/ywireless-rx111/source/startup/iar/: cstartup.s
