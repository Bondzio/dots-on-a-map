# IAR project OS3-TCPIP-WIFI.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F565N9 R5F565N9
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x400
  General.HeapSize: 0x400
  ICCRX.CCDefines: RX65N
  ICCRX.CCIncludePath2: ..\; ..\..\BSP\include; ..\..\..\..\..\Software\uC-CLK; ..\..\..\..\..\Software\uC-CLK\Source; ..\..\..\..\..\Software\uC-CPU; ..\..\..\..\..\Software\uC-CPU\RX\IAR; ..\..\..\..\..\Software\uC-LIB; ..\..\..\..\..\Software\uCOS-III\; ..\..\..\..\..\Software\uCOS-III\Source; ..\..\..\..\..\Software\uCOS-III\Ports\Renesas\RX\IAR; ..\..\..\..\..\Software\uC-Common; ..\..\..\..\..\Software\uC-DHCPc; ..\..\..\..\..\Software\uC-DHCPc\Source; ..\..\..\..\..\Software\uC-DNSc; ..\..\..\..\..\Software\uC-DNSc\Source; ..\..\..\..\..\Software\uC-MQTT; ..\..\..\..\..\Software\uC-MQTT\Common; ..\..\..\..\..\Software\uC-MQTT\Client\Source; ..\..\..\..\..\Software\uC-TCPIP; ..\..\..\..\..\Software\uC-TCPIP\Source; ..\..\..\..\..\Software\uC-TCPIP\Secure; ..\..\..\..\..\Software\uC-TCPIP\Secure\Mocana; ..\..\..\..\..\Software\uC-TCPIP\Dev\WiFi\QCA400x\atheros_wifi\common_src\include; ..\..\..\..\..\Software\uC-TCPIP\Dev\WiFi\QCA400x\atheros_wifi\custom_src\include; ..\..\..\..\..\Software\uC-TCPIP\Dev\WiFi\QCA400x\atheros_wifi\include; ..\..\..\..\..\Software\uC-TCPIP\Dev\WiFi\QCA400x; ..\..\..\..\..\Software\uC-TCPIP\Dev\WiFi\QCA400x\atheros_wifi; ..\..\..\..\..\Software\uC-TCPIP\Dev\WiFi\QCA400x\atheros_wifi\include\AR6002; ..\..\..\..\..\Software\uC-TCPIP\Dev\WiFi\QCA400x\atheros_wifi\common_src\stack_common; ..\..\..\..\..\Software\uC-TCPIP\Dev\WiFi\QCA400x\atheros_wifi\common_src\wmi; ..\..\..\..\..\..\Mocana
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: OS3-TCPIP-WIFI.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\BSP\cfg\iar\lnkr5f565n9.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../: app_cfg.h app_dhcp-c.c app_dhcp-c.h app_main.c aws_iot.c aws_iot.h aws_iot_cert.h bsp_cfg.h cli.c cli.h clk_cfg.c clk_cfg.h cpu_cfg.h dhcp-c_cfg.h dns-c_cfg.c dns-c_cfg.h lib_cfg.h lora_gw.c lora_gw.h m1_bsp.h mqtt-c_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h sx1276.c sx1276.h
  group APP/TCP-IP
    ../: app_tcpip.c app_tcpip.h net_cfg.c net_cfg.h net_dev_cfg.c net_dev_cfg.h
  group BSP/cfg/iar
    ../../BSP/cfg/iar/: lnkr5f565n9.icf
  group BSP/include
    ../../BSP/include/: bsp.h bsp_clk.h bsp_int_vect_tbl.h bsp_led.h bsp_os.h bsp_pb.h bsp_spi.h bsp_uart.h iorx651.h net_bsp_gt202.h r_flash_rx.h r_flash_rx65n.h r_flash_rx_config.h r_flash_rx_if.h r_flash_type4_if.h r_mcu_config.h
  group BSP/source
    ../../BSP/source/: bsp.c bsp_clk.c bsp_int_vect_tbl.c bsp_led.c bsp_os.c bsp_pb.c bsp_spi.c bsp_uart.c cpu_bsp.c net_bsp_gt202.c r_flash_rx.c r_flash_type4.c
  group Mocana/asn1
    ../../../../../../Mocana/asn1/: ASN1TreeWalker.c ASN1TreeWalker.h derencoder.c derencoder.h oiddefs.c oiddefs.h oidutils.c oidutils.h parseasn1.c parseasn1.h parsecert.c parsecert.h
  group Mocana/common
    ../../../../../../Mocana/common/: absstream.c absstream.h altivec.c asm_math.h constants.h datetime.c datetime.h debug_console.c debug_console.h dynarray.c dynarray.h hash_table.c hash_table.h hash_value.c hash_value.h int128.c int128.h int64.c int64.h jacobi.c jacobi.h lucas.c lucas.h math_386.h math_386_gcc.h math_arm.h math_coldfire.h math_h8s.h math_mips.h math_ppc.h mbitmap.c mbitmap.h mdefs.h mem_part.c mem_part.h mem_pool.c mem_pool.h memfile.c memfile.h memory_debug.c memory_debug.h merrors.c merrors.h mlimits.h moc_net.c moc_net.h mocana.c mocana.h moptions.h moptions_custom.h mrtos.c mrtos.h mstdlib.c mstdlib.h mtcp.c mtcp.h mtcp_async.h mtypes.h mudp.h prime.c prime.h random.c random.h redblack.c redblack.h rng_seed.c rng_seed.h sizedbuffer.c sizedbuffer.h tree.c tree.h uri.c uri.h utils.c utils.h vlong.c vlong.h
  group Mocana/crypto
    ../../../../../../Mocana/crypto/: aes.c aes.h aes_ccm.c aes_ccm.h aes_cmac.c aes_cmac.h aes_ctr.c aes_ctr.h aes_keywrap.c aes_keywrap.h aesalgo.c aesalgo.h ansix9_63_kdf.c ansix9_63_kdf.h arc2.c arc2.h arc4.c arc4.h asn1cert.c asn1cert.h base64.h base64m.c ca_mgmt.c ca_mgmt.h cert_store.c cert_store.h cms.h cms_aux.h crypto.c crypto.h des.c des.h dh.c dh.h dsa.c dsa.h dsa2.c dsa2.h fips.c fips.h gcm.h hmac.c hmac.h hw_accel.h md2.c md2.h md4.c md4.h md45.c md45.h md5.c md5.h mem_part.h nil.c nil.h nist_rng.c nist_rng.h nist_rng_types.h pkcs.c pkcs.h pkcs1.c pkcs1.h pkcs10.c pkcs10.h pkcs12.c pkcs12.h pkcs5.c pkcs5.h pkcs7.c pkcs7.h pkcs8.c pkcs8.h pkcs_common.c pkcs_common.h pkcs_key.c pkcs_key.h primeec.h primeec_priv.h primefld.h primefld_priv.h pubcrypto.c pubcrypto.h rc2algo.c rc2algo.h rc4algo.c rc4algo.h rsa.c rsa.h sec_key.c sec_key.h secmod.h sha1.c sha1.h sha256.c sha256.h sha512.c sha512.h three_des.c three_des.h
  group Mocana/harness
    ../../../../../../Mocana/harness/: harness.h
  group Mocana/ocsp
    ../../../../../../Mocana/ocsp/: ocsp.c ocsp_context.c ocsp_http.c ocsp_message.c
  group Mocana/platform
    ../../../../../../Mocana/platform/: uc_tcp.c ucos_rtos.c
  group Mocana/ssl
    ../../../../../../Mocana/ssl/: ssl.c ssl.h ssl_ocsp.c ssl_ocsp.h ssl_util.c ssl_util.h sslsock.c sslsock.h sslsock_priv.h
  group Mocana/ssl/client
    ../../../../../../Mocana/ssl/client/: ssl_client.inc
  group Mocana/ssl/server
    ../../../../../../Mocana/ssl/server/: ssl_server.inc
  group uC-CPU
    ../../../../../Software/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uC-CPU/RX/IAR
    ../../../../../Software/uC-CPU/RX/IAR/: cpu.h
  group uC-LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/CLK/Source
    ../../../../../Software/uC-CLK/Source/: clk.c clk.h clk_type.h
  group uC/Common
    ../../../../../Software/uC-Common/: common.h common_err.h
  group uC/Common/Collections
    ../../../../../Software/uC-Common/Collections/: slist.c slist.h
  group uC/Common/KAL
    ../../../../../Software/uC-Common/KAL/: kal.h
  group uC/Common/KAL/uC/OS-III
    ../../../../../Software/uC-Common/KAL/uCOS-III/: kal.c
  group uC/DHCPc/OS/uCOS-III
    ../../../../../Software/uC-DHCPc/OS/uCOS-III/: dhcp-c_os.c
  group uC/DHCPc/Source
    ../../../../../Software/uC-DHCPc/Source/: dhcp-c.c dhcp-c.h
  group uC/DNSc/Source
    ../../../../../Software/uC-DNSc/Source/: dns-c.c dns-c.h dns-c_cache.c dns-c_cache.h dns-c_req.c dns-c_req.h dns-c_task.c dns-c_task.h dns-c_type.h
  group uC/MQTT/Common
    ../../../../../Software/uC-MQTT/Common/: mqtt.h
  group uC/MQTT/Common/Client/Source
    ../../../../../Software/uC-MQTT/Client/Source/: mqtt-c.c mqtt-c.h mqtt-c_sock.c mqtt-c_sock.h
  group uC/TCP-IP/Dev/WiFi/Manager/Generic
    ../../../../../Software/uC-TCPIP/Dev/WiFi/Manager/Generic/: net_wifi_mgr.c net_wifi_mgr.h
  group uC/TCP-IP/Dev/WiFi/QCA400x
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/: net_dev_qca400x.c net_dev_qca400x.h
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/: atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/api_interface
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/bmi
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/bmi/: bmi.c
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/driver
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/hcd
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/hcd/: spi_hcd.c
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/htc
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/htc/: htc.c
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/hw_interface
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/hw_interface/: hw_api.c
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/include
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h dset.h dset_api.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/reorder
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/reorder/: rcv_aggr.c
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/stack_common
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/stack_common/: common_stack_offload.h
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/storerecall
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/storerecall/: dset.c dset_api.c storerecall.c
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/util
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/util/: util.c
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/common_src/wmi
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/common_src/wmi/: wmi.c wmi_host.h
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/custom_src/driver
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/custom_src/hw_interface
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/custom_src/hw_interface/: cust_hw_api.c
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/custom_src/include
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/custom_src/include/: a_config.h a_osapi.h a_types.h athendpack.h athstartpack.h cust_context.h cust_netbuf.h custom_api.h kal_lock_port.h wlan_config.h
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/include
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h targaddrs.h wlan_defs.h wmi.h
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/include/AR6002
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/include/AR6002/: AR6K_version.h
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/include/AR6002/hw2.0/hw
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/include/AR6002/hw2.0/hw/: apb_map.h gpio_reg.h mbox_host_reg.h mbox_reg.h rtc_reg.h si_reg.h uart_reg.h vmc_reg.h
  group uC/TCP-IP/Dev/WiFi/QCA400x/atheros_wifi/include/AR6002/hw4.0/hw
    ../../../../../Software/uC-TCPIP/Dev/WiFi/QCA400x/atheros_wifi/include/AR6002/hw4.0/hw/: rtc_reg.h rtc_wlan_reg.h
  group uC/TCP-IP/IF
    ../../../../../Software/uC-TCPIP/IF/: net_if.c net_if.h net_if_802x.c net_if_802x.h net_if_ether.c net_if_ether.h net_if_loopback.c net_if_loopback.h net_if_wifi.c net_if_wifi.h
  group uC/TCP-IP/IP/IPv4
    ../../../../../Software/uC-TCPIP/IP/IPv4/: net_arp.c net_arp.h net_icmpv4.c net_icmpv4.h net_igmp.c net_igmp.h net_ipv4.c net_ipv4.h
  group uC/TCP-IP/IP/IPv6
    ../../../../../Software/uC-TCPIP/IP/IPv6/: net_dad.c net_dad.h net_icmpv6.c net_icmpv6.h net_ipv6.c net_ipv6.h net_mldp.c net_mldp.h net_ndp.c net_ndp.h
  group uC/TCP-IP/Secure
    ../../../../../Software/uC-TCPIP/Secure/: net_secure.h
  group uC/TCP-IP/Secure/Mocana
    ../../../../../Software/uC-TCPIP/Secure/Mocana/: net_secure_mocana.c net_secure_mocana.h
  group uC/TCP-IP/Source
    ../../../../../Software/uC-TCPIP/Source/: net.c net.h net_app.c net_app.h net_ascii.c net_ascii.h net_bsd.c net_bsd.h net_buf.c net_buf.h net_cache.c net_cache.h net_cfg_net.h net_conn.c net_conn.h net_ctr.c net_ctr.h net_def.h net_err.h net_icmp.c net_icmp.h net_ip.c net_ip.h net_mgr.c net_mgr.h net_sock.c net_sock.h net_stat.c net_stat.h net_tcp.c net_tcp.h net_tmr.c net_tmr.h net_type.h net_udp.c net_udp.h net_util.c net_util.h
  group uCOS-III/Ports/RX/IAR
    ../../../../../Software/uCOS-III/Ports/Renesas/RX/IAR/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOS-III/Source
    ../../../../../Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
